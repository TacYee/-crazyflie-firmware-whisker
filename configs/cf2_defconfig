## configs/tag_defconfig
```kconfig
CONFIG_PLATFORM_TAG=y

CONFIG_ESTIMATOR_AUTO_SELECT=y
CONFIG_CONTROLLER_AUTO_SELECT=y

CONFIG_="bcLoco"
CONFIG_SENSORS_IGNORE_BAROMETER_FAIL=y
```
